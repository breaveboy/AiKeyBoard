# Keil uVision project py32f403r1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32F403xC Puya
  pack: Puya.PY32F4xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: py32f403r1 +hex
  AfterMake: D:\sike_local\AiKeyBoard\Project\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F403xC,HSE_VALUE=8000000
  c include: ..\User\Inc;..\Frimware\Inc;..\CherryUSB\class\hid;..\CherryUSB\class\cdc;..\CherryUSB\common;..\CherryUSB\core;..\CherryUSB\port;..\..\..\Keil_v5\Packs\Puya\PY32F4xx_DFP\1.0.6\Drivers\CMSIS\Device\PUYA\PY32F4xx\Include;..\Bsp\inc;..\Lib\inc;..\App\inc;..\SEGGER_RTT_V754a\RTT;..\SEGGER_RTT_V754a\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Com
    ../Com/: startup_py32f403xx.s system_py32f403.c
  group App
    ../App/src/: App.c App_protocol.c App_key.c App_lighting.c App_usb.c
    ../App/inc/: App.h App_key.h
  group User
    ../User/Src/: main.c py32f403_hal_msp.c py32f403_it.c usbd_hid_keyboard_if.c task.c
    ../User/Inc/: task.h
  group Bsp
    ../Bsp/inc/: bsp_config.h bsp_board.h
    ../Bsp/src/: bsp_adc_dma.c bsp_spi_dma.c bsp_tim.c bsp_uart.c bsp_gpio.c bsp_delay.c
  group Lib
    ../Lib/inc/: lib_config.h
    ../Lib/src/: lib_hall_sensor.c lib_ws2812.c
  group CherryUSB
    ../CherryUSB/class/hid/: usbd_hid.c
    ../CherryUSB/core/: usbd_core.c
    ../CherryUSB/port/: usb_dc_py32.c
  group Frimware
    ../Frimware/Src/: py32f403_hal.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_canfd.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_ctc.c py32f403_hal_dac.c py32f403_hal_dac_ex.c py32f403_hal_dma.c py32f403_hal_esmc.c py32f403_hal_exti.c py32f403_hal_flash.c py32f403_hal_gpio.c py32f403_hal_i2c.c py32f403_hal_i2s.c py32f403_hal_irda.c py32f403_hal_iwdg.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rtc.c py32f403_hal_rtc_ex.c py32f403_hal_sd.c py32f403_hal_smartcard.c py32f403_hal_spi.c py32f403_hal_spi_ex.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_wwdg.c
  group SEGGER_RTT
    ../SEGGER_RTT_V754a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0
